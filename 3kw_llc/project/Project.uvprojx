# Keil uVision project Project.uvprojx, settings and files
target 3KW_LLC (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F334C8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20002FFF) IRAM2(0x10000000-0x10000FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: 3KW_LLC_SW +hex
  c flags: Optim=3 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F334x8,USE_HAL_DRIVER,USE_STM32F3348_DISCO
  c misc: --C99
  c include: ..\libs\Inc;..\app;..\libs\CMSIS\Include;..\cmsis_core
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x10000000 size 0x1000
  link misc: --diag_suppress=L6329
  group Core
    ../cmsis_core/: startup_stm32f334x8.s system_stm32f3xx.c
  group App
    ../app/: main.c stm32f3xx_hal_msp.c stm32f3xx_it.c uart_debug.c globaldefine.h
  group Libs
    ../libs/Src/: stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_comp.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dac.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_hrtim.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_wwdg.c
software components: CMSIS:CORE 4.1.0
